# Keil uVision project cs_timer_iproc.uvprojx, settings and files
target CS Timer IPROC SIM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cs_timer_irq
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SE350_DEMO DEGUG_0 K_MSG_ENV SIM_TARGET TIMER_IPROC AE_ENABLE
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Documentation
    ./: Abstract.txt
    ./doc/: README_AE.txt
  group System Code
    ./src/: main_svc.c printf.c uart_polling.c
  group Kernel
    ./src/: HAL.c k_memory.c k_msg.c k_process.c k_rtx_init.c
  group Interrupt
    ./src/: timer.c
  group AE
    ./src/: ae.c ae_util.c ae_timer.c
  group AE-active
    ./src/: ae_proc.c
  group AE-pub-inactive
    ./src/: ae_proc201.c ae_proc202.c ae_proc211.c ae_proc212.c
target CS Timer IPROC RAM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: as above
  output: cs_timer_irq
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SE350_DEMO K_MSG_ENV DEGUG_0 TIMER_IPROC AE_ENABLE
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
